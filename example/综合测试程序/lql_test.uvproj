# Keil uVision project lql_test.uvproj, settings and files
target lql_test (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: lql_test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c stc12.h iic.c LCD1602.c LCD1602.h Uart.c Uart.h delay.h delay.c DS18B20.h
